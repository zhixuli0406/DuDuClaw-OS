SUMMARY = "DuDuClaw agent gateway + CLI (single `duduclaw` binary)"
DESCRIPTION = "The `duduclaw` binary -- both roles the Y2-1 task brief names \
separately (\"duduclaw gateway\" and \"duduclaw-cli\") turn out to be the \
SAME ELF: duduclaw-gateway is a library crate with no [[bin]] of its own, \
duduclaw-cli's src/bin/duduclaw.rs is the only binary, and `duduclaw run` \
is what duduclaw-gateway.service execs. One recipe, one package, both jobs. \
Built --no-default-features --features duduclaw-gateway/dashboard, matching \
container/Dockerfile.server's rust-builder stage (avoids enigo/xcap and the \
wayland/pipewire/gbm pull-in the desktop feature drags in on Linux). \
Source: a mini-workspace snapshot of crates/duduclaw-cli + the other \
DuDuClaw crates it reaches by path, generated by refresh-src.sh -- see that \
script's header comment for why a snapshot (not S pointed at the monorepo \
directly) and why a mini-workspace (not a single flattened crate the way \
duduclaw-sysd's recipe does it)."
HOMEPAGE = "https://github.com/duduclaw/duduclaw"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=87e8e4a396af46e141a08fbc9f1b0455"

# Real native-dependency gap, hit by actually running do_compile:
# openssl-sys (a transitive dep of reqwest/rusqlite's tls stack -- some
# transitive dep picks openssl-sys over rustls despite rustls also being in
# the graph) needs pkg-config to find OpenSSL for the TARGET
# (x86_64-poky-linux-gnu), and neither pkg-config itself nor a target
# OpenSSL sysroot were present: "Could not run `... pkg-config --libs
# --cflags openssl`: The pkg-config command could not be found." `inherit
# pkgconfig` wires PKG_CONFIG_PATH/pkgconfig-native the standard OE way;
# `openssl` in DEPENDS populates the target recipe-sysroot with libssl/
# libcrypto + their .pc files for openssl-sys to find via pkg-config.
DEPENDS += "openssl"
inherit cargo cargo-update-recipe-crates pkgconfig

# See duduclaw-sysd's recipe for why S is UNPACKDIR- not WORKDIR-relative.
SRC_URI = "file://duduclaw-cli-src"
S = "${UNPACKDIR}/duduclaw-cli-src"

require duduclaw-cli-crates.inc

# The one git (non-crates.io) dependency in the v1.73.1 snapshot's lock:
# duduclaw-inference depends on `ucci` (MIT) by git rev, unconditionally.
# `bitbake -c update_crates` only emits crates.io entries, so it lives here
# (update_crates rewrites the .inc). cargo_common.bbclass's
# do_patch_paths turns every named git SRC_URI with a destsuffix into a
# `[patch."https://github.com/varunkotte6/ucci"]` path override and strips
# the `source = "git+…"` lines from the lock so `--frozen` still holds. The
# crate is in the repo's rust/ subdirectory, hence subpath=rust (its tree
# lands directly in ${UNPACKDIR}/ucci). Keep the rev in step with
# crates/duduclaw-inference/Cargo.toml on every platform sync.
SRC_URI += "git://github.com/varunkotte6/ucci;protocol=https;nobranch=1;name=ucci;subpath=rust;destsuffix=ucci"
SRCREV_ucci = "80cd2319cc2b41e3a5c35a64acd6b5dcbf5c217b"
# do_patch_paths edits the lock at CARGO_LOCK_PATH, which defaults to the
# directory of CARGO_SRC_DIR's manifest (crates/duduclaw-cli/, no lock
# there). The workspace lock is at the snapshot root.
CARGO_LOCK_PATH = "${S}/Cargo.lock"

# Build the CLI and maintenance-tools packages out of the mini
# workspace, not every member's own [[bin]] (duduclaw-sysd is also a
# workspace member here because duduclaw-cli reaches it by path, but this
# recipe isn't the place that installs its binary -- duduclaw-sysd has its
# own recipe already).
CARGO_SRC_DIR = "crates/duduclaw-cli"

# Appliance convention (container/Dockerfile.server's rust-builder stage):
# dashboard on, desktop off -- desktop pulls enigo/xcap, which on Linux pull
# wayland/pipewire/gbm this recipe has no business depending on.
# `app-compat` (2026-09-29, platform feature audit S15): the `duduclaw compat`
# subcommand family (compat.d runner registry + `windows-vm` RemoteApp
# bootstrap) is OS-only, so the platform binary no longer compiles it by
# default. This image DOES need it -- duduclaw-shell spawns
# `duduclaw compat windows-vm app ...` and compat.d/windows-vm.toml names it
# as its entrypoint -- hence the feature must be turned on here.
#
# Swapped on 2026-10-13 with the platform v1.73.1 sync: that snapshot's
# duduclaw-cli Cargo.toml carries `app-compat = ["duduclaw-core/app-compat"]`,
# and without it the image would lose `duduclaw compat`.
CARGO_BUILD_FLAGS:append = " --package duduclaw-cli --package duduclaw-maint-tools --no-default-features --features duduclaw-gateway/dashboard,app-compat"
# 2026-09-08 (fix14 bake, twice in a row): cargo.bbclass's CARGO_BUILD_FLAGS
# carries no `-j`, so cargo spawns nproc rustc jobs regardless of
# PARALLEL_MAKE / BB_NUMBER_THREADS (neither reaches cargo). The
# duduclaw-gateway lib rustc and the duduclaw-cli rustc each need several GB;
# side by side on the 12 GB builder the kernel SIGKILLed one of them
# (`(signal: 9, SIGKILL: kill)`, cargo exit 101, no diagnostic at all) — with
# `-j 2` and with `-j 1` make flags alike. One rustc at a time for this
# megacrate; the small crates before it are cheap enough not to matter.
CARGO_BUILD_FLAGS:append = " -j 1"

# Y2-3 (2026-08-25) real fix for do_package_qa's buildpaths QA failure, hit
# by actually running bitbake:
#   "ERROR: QA Issue: File /usr/bin/duduclaw in package duduclaw-cli
#    contains reference to TMPDIR [buildpaths]"
# `strings` on the offending binary showed the leaked paths are C sources
# from a vendored crate's build.rs (tree-sitter's C runtime -- stack.c,
# tree_cursor.c, etc. -- compiled via the `cc` crate, not rustc), all
# rooted at ${WORKDIR}/sources/cargo_home/bitbake/tree-sitter-<ver>/... --
# the crate:// fetcher's unpack location (cargo-update-recipe-crates.
# bbclass), NOT ${S} or ${B}. rust-common.bbclass already remaps the
# equivalent leak on the Rust side (RUST_DEBUG_REMAP =
# "--remap-path-prefix=${WORKDIR}=${TARGET_DBGSRC_DIR}", covers the whole
# WORKDIR tree via rustc's own flag) but that flag only reaches rustc
# invocations. The C side gets DEBUG_PREFIX_MAP via cargo_common.bbclass's
# `export CFLAGS="${CFLAGS}"`, but DEBUG_PREFIX_MAP (bitbake.conf) only maps
# ${S} and ${B} specifically -- neither covers ${WORKDIR}/sources/cargo_home,
# a THIRD directory under WORKDIR that cc-rs's build script compiles from.
# Fix: mirror the same WORKDIR-wide remap Rust already gets, for CFLAGS/
# CXXFLAGS, using the same -ffile-prefix-map mechanism DEBUG_PREFIX_MAP
# itself already uses (not -fdebug-prefix-map -- -ffile-prefix-map also
# remaps __FILE__/__BASE_FILE__ macro expansions, which is what actually
# leaked here: tree-sitter's C runtime uses assert() macros that stringize
# __FILE__ into the binary's .rodata independent of any -g debug info).
# Appended after DEBUG_PREFIX_MAP's own -ffile-prefix-map=${S}=... /
# -ffile-prefix-map=${B}=... entries, so those more specific mappings still
# win for anything under S/B; this one only adds coverage for the region
# they don't reach. Verified by rebuilding and re-running do_package_qa
# after this change -- see the Y line TODO entry for the pass evidence, not
# assumed from the flag alone.
CFLAGS:append = " -ffile-prefix-map=${WORKDIR}=${TARGET_DBGSRC_DIR}"
CXXFLAGS:append = " -ffile-prefix-map=${WORKDIR}=${TARGET_DBGSRC_DIR}"

SRC_URI += "file://duduclaw-gateway.service"
SRC_URI += "file://duduclaw-home-profile.sh"
SRC_URI += " \
    file://duduclaw-home-owner.service \
    file://duduclaw-home.conf \
    file://duduclaw-gateway.conf \
    file://relocate-root-state.sh \
    file://50-duduclaw-protected-links.conf \
    file://50-duduclaw-ptrace.conf \
    file://50-duduclaw-tiocsti.conf \
"

# --- Service account (rootless gateway, 2026-10-15) ------------------------
# duduclaw-gateway.service runs as `duduclaw`, uid/gid 1000. Fixed ids, not
# dynamic ones: the gateway's files on /data survive A/B updates and a
# rollback, so the owner id has to be the same in every image ever built.
# 1000 is the Debian line's value (appliance/postinst.d/20-users-and-units.sh
# `useradd -r -g duduclaw -u 1000`) and stays clear of the range shadow
# hands out to --system accounts (999 downwards). Not yet verified on a
# built image that nothing else claims 1000 (`getent passwd 1000`,
# `getent group 1000`, V1 in wiki/eval/rootless-verification-2026-10.md).
#
# Groups:
#   duduclaw      primary group, gid 1000. It used to be created (with a
#                 dynamic gid) by duduclaw-flatpak-kiosk-verify, and the
#                 Flatpak polkit rule granted it every Flatpak action. That
#                 grant now keys on the empty `duduclaw-flatpak` group
#                 (duduclaw-polkit-flatpak), so the gateway gets no Flatpak
#                 rights from this group.
#   duduclaw-ipc  the group duduclaw-comp gives its shell-control and
#                 codrive sockets (0660) and codrive token (0640). Members:
#                 this account and duduclaw-kiosk (GROUPMEMS below), and no
#                 one else; in particular duduclaw-flatpak-verify, which is
#                 in duduclaw-kiosk to reach the Wayland socket, is not.
#   duduclaw-kiosk  (secondary) lets the gateway traverse /run/duduclaw-kiosk
#                 (0750) to reach those sockets (not PipeWire: its sockets
#                 stay 0600, volume goes through comp verbs).
#
# USERADD_DEPENDS + RDEPENDS on duduclaw-shell: duduclaw-kiosk (user and
# group) comes from that recipe. USERADD_DEPENDS makes it exist in this
# recipe's sysroot passwd database, RDEPENDS makes the package manager
# install it (and run its useradd preinst) before this package's. Every
# image that installs duduclaw-cli already installs duduclaw-shell through
# duduclaw-image-desktop.inc, so this adds nothing to any image.
inherit useradd
USERADD_PACKAGES = "${PN}"
GROUPADD_PARAM:${PN} = "--system --gid 1000 duduclaw; --system duduclaw-ipc"
USERADD_PARAM:${PN} = "--system --uid 1000 --gid duduclaw --home-dir /data/duduclaw --no-create-home --shell /sbin/nologin --groups duduclaw-ipc,duduclaw-kiosk duduclaw"
GROUPMEMS_PARAM:${PN} = "-a duduclaw-kiosk -g duduclaw-ipc"
USERADD_DEPENDS = "duduclaw-shell"
RDEPENDS:${PN} += "duduclaw-shell"
# setpriv: the supported way for root (an operator shell, firstboot) to run
# something as the gateway account; runuser is not built without PAM.
RDEPENDS:${PN} += "util-linux-setpriv"
# setsid -w (util-linux; busybox setsid has no -w): the profile.d function
# runs a non-interactive `duduclaw` without the root shell's terminal.
RDEPENDS:${PN} += "util-linux-setsid"

do_install:append() {
    install -d ${D}${systemd_system_unitdir}
    # UNPACKDIR, not WORKDIR -- see duduclaw-sysd's recipe for the exact
    # error this fixes (hit it for real there first).
    install -m 0644 ${UNPACKDIR}/duduclaw-gateway.service ${D}${systemd_system_unitdir}/duduclaw-gateway.service
    # Interactive-shell DUDUCLAW_HOME — see the file's own header for the
    # live-fire divergence (root CLI writing /root/.duduclaw while the
    # launcher reads /data/duduclaw) this closes.
    install -d ${D}${sysconfdir}/profile.d
    install -m 0644 ${UNPACKDIR}/duduclaw-home-profile.sh ${D}${sysconfdir}/profile.d/duduclaw-home.sh

    # Rootless gateway (2026-10-15): ownership oneshot + its tmpfiles file
    # (private path on purpose, see duduclaw-home.conf's header), the
    # /run/duduclaw-gateway runtime dir, the one-time relocation of
    # root-only state out of the home, and the two sysctl files the
    # tmpfiles walk and the sysd caller check rely on.
    install -m 0644 ${UNPACKDIR}/duduclaw-home-owner.service ${D}${systemd_system_unitdir}/duduclaw-home-owner.service
    install -d ${D}${datadir}/duduclaw/tmpfiles.d
    install -m 0644 ${UNPACKDIR}/duduclaw-home.conf ${D}${datadir}/duduclaw/tmpfiles.d/duduclaw-home.conf
    install -d ${D}${nonarch_libdir}/tmpfiles.d
    install -m 0644 ${UNPACKDIR}/duduclaw-gateway.conf ${D}${nonarch_libdir}/tmpfiles.d/duduclaw-gateway.conf
    install -d ${D}${libexecdir}/duduclaw
    install -m 0755 ${UNPACKDIR}/relocate-root-state.sh ${D}${libexecdir}/duduclaw/relocate-root-state.sh
    install -d ${D}${nonarch_libdir}/sysctl.d
    install -m 0644 ${UNPACKDIR}/50-duduclaw-protected-links.conf ${D}${nonarch_libdir}/sysctl.d/50-duduclaw-protected-links.conf
    install -m 0644 ${UNPACKDIR}/50-duduclaw-ptrace.conf ${D}${nonarch_libdir}/sysctl.d/50-duduclaw-ptrace.conf
    install -m 0644 ${UNPACKDIR}/50-duduclaw-tiocsti.conf ${D}${nonarch_libdir}/sysctl.d/50-duduclaw-tiocsti.conf
}

inherit systemd
SYSTEMD_SERVICE:${PN} = "duduclaw-gateway.service duduclaw-home-owner.service"
SYSTEMD_AUTO_ENABLE:${PN} = "enable"

FILES:${PN} += " \
    ${systemd_system_unitdir}/duduclaw-gateway.service \
    ${systemd_system_unitdir}/duduclaw-home-owner.service \
    ${datadir}/duduclaw/tmpfiles.d/duduclaw-home.conf \
    ${nonarch_libdir}/tmpfiles.d/duduclaw-gateway.conf \
    ${libexecdir}/duduclaw/relocate-root-state.sh \
    ${nonarch_libdir}/sysctl.d/50-duduclaw-protected-links.conf \
    ${nonarch_libdir}/sysctl.d/50-duduclaw-ptrace.conf \
    ${nonarch_libdir}/sysctl.d/50-duduclaw-tiocsti.conf \
"

# The maintenance menu shares the tested platform snapshot and dependency
# lock with the CLI, but is a separate package: the account recipe pulls it
# in explicitly. cargo.bbclass installs every built executable in bindir;
# relocate these two before packaging, leaving no general command entrypoint.
PACKAGES =+ "duduclaw-maint-tools"
SUMMARY:duduclaw-maint-tools = "Restricted maintenance SSH menu and root helper"
FILES:duduclaw-maint-tools = "${libexecdir}/duduclaw/maint-shell ${libexecdir}/duduclaw/maint-helper"
RDEPENDS:duduclaw-maint-tools = "systemd iproute2 procps coreutils"

do_install:append() {
    install -d ${D}${libexecdir}/duduclaw
    install -m 0755 ${D}${bindir}/duduclaw-maint-shell ${D}${libexecdir}/duduclaw/maint-shell
    install -m 0700 ${D}${bindir}/duduclaw-maint-helper ${D}${libexecdir}/duduclaw/maint-helper
    rm ${D}${bindir}/duduclaw-maint-shell ${D}${bindir}/duduclaw-maint-helper
}
