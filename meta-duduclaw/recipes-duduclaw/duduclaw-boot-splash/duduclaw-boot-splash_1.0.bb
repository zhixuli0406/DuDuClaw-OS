SUMMARY = "DuDuClaw OS boot splash (Plymouth two-step theme, C1 identity)"
DESCRIPTION = "${SUMMARY}. Added 2026-10-16 with the C1 rebrand: until then \
the image had no splash at all (systemd-boot timeout 0, no Plymouth, no \
psplash). Installs the 'duduclaw' Plymouth theme (the C1 cat mark in cream \
and amber, centred on #0B1E33, with a small amber spinner), plus two \
systemd drop-ins that keep the splash from getting in the way: the kiosk \
session is ordered after plymouth-quit.service (plymouthd holds DRM master \
until it quits, duduclaw-comp needs it), and the rescue shell quits any \
running splash before it takes tty1. Selecting the theme is plymouth's own \
job (recipes-core/plymouth/plymouth_%.bbappend points plymouthd.defaults \
at it); wiring the package and the kernel arguments into an image is \
recipes-core/images/duduclaw-image-splash.inc. Config/asset-only package, \
same shape as duduclaw-journald.bb."
HOMEPAGE = "https://github.com/zhixuli0406/DuDuClaw-OS"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/MIT;md5=0835ade698e0bcf8506ecda2f7b4f302"

# The theme PNGs are generated by scripts/brand/derive-c1-assets.py from
# appliance/branding/duduclaw-os-mark.svg; regenerate them there, do not edit.
THROBBER_FRAMES = "0001 0002 0003 0004 0005 0006 0007 0008 0009 0010 0011 0012 \
                   0013 0014 0015 0016 0017 0018 0019 0020 0021 0022 0023 0024 \
                   0025 0026 0027 0028 0029 0030 0031 0032 0033 0034 0035 0036"

SRC_URI = " \
    file://theme/duduclaw.plymouth \
    file://theme/watermark.png \
    file://theme/lock.png \
    file://theme/entry.png \
    file://theme/bullet.png \
    ${@' '.join('file://theme/throbber-%s.png' % f for f in d.getVar('THROBBER_FRAMES').split())} \
    file://duduclaw-kiosk-after-plymouth.conf \
    file://duduclaw-rescue-shell-quit-plymouth.conf \
"

S = "${UNPACKDIR}"

PLYMOUTH_THEME_DIR = "${datadir}/plymouth/themes/duduclaw"

do_install() {
    install -d ${D}${PLYMOUTH_THEME_DIR}
    install -m 0644 ${UNPACKDIR}/theme/duduclaw.plymouth ${D}${PLYMOUTH_THEME_DIR}/duduclaw.plymouth
    for f in watermark lock entry bullet; do
        install -m 0644 ${UNPACKDIR}/theme/$f.png ${D}${PLYMOUTH_THEME_DIR}/$f.png
    done
    for n in ${THROBBER_FRAMES}; do
        install -m 0644 ${UNPACKDIR}/theme/throbber-$n.png ${D}${PLYMOUTH_THEME_DIR}/throbber-$n.png
    done

    # The theme file hard-codes ImageDir; fail the build rather than ship a
    # theme that points somewhere else (plymouth would fall back to the text
    # splash at boot, silently).
    grep -qx "ImageDir=${PLYMOUTH_THEME_DIR}" ${D}${PLYMOUTH_THEME_DIR}/duduclaw.plymouth || \
        bbfatal "duduclaw.plymouth's ImageDir does not match ${PLYMOUTH_THEME_DIR}"

    install -d ${D}${systemd_system_unitdir}/duduclaw-kiosk.service.d
    install -m 0644 ${UNPACKDIR}/duduclaw-kiosk-after-plymouth.conf \
        ${D}${systemd_system_unitdir}/duduclaw-kiosk.service.d/10-after-plymouth.conf
    install -d ${D}${systemd_system_unitdir}/duduclaw-rescue-shell@.service.d
    install -m 0644 ${UNPACKDIR}/duduclaw-rescue-shell-quit-plymouth.conf \
        ${D}${systemd_system_unitdir}/duduclaw-rescue-shell@.service.d/10-quit-plymouth.conf
}

# The two drop-in FILES are listed individually, not by directory:
# duduclaw-live-tweaks installs its own drop-in (10-live-root.conf) into the
# same duduclaw-kiosk.service.d/ on the live image.
FILES:${PN} = " \
    ${PLYMOUTH_THEME_DIR} \
    ${systemd_system_unitdir}/duduclaw-kiosk.service.d/10-after-plymouth.conf \
    ${systemd_system_unitdir}/duduclaw-rescue-shell@.service.d/10-quit-plymouth.conf \
"

RDEPENDS:${PN} = "plymouth"

inherit allarch
